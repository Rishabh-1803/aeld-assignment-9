SRC_URI:remove = "file://0001-qemu-Add-missing-wacom-HID-descriptor.patch"
